Commit message: added more complex training environment

File: urdf/cube5x5.xacro (robot description, xacro)
@@ -28,5 +28,5 @@
     <mu1> 20 </mu1>
     <mu2> 30 </mu2>
-    <material> Gazebo/White </material>
+    <material> Gazebo/Blue </material>
   </gazebo>
 </robot>
